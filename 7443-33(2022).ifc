Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-03-21T14:00:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 21 14:00:49 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{7A52906C-9BB6-46C4-84CA-6F0BDB532CE4}\ifc * Database version: 5507 * Database creation date: Mon Mar 21 14:00:49 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 21 14:00:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 21 14:00:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7432G Shower faucet with shower set, 40cc, 7443-33(2022):7432G Shower faucet with shower set, 40cc:470430
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 159 mm; NominalHeight: 72 mm; NominalWidth: 290 mm
Type - General - Author: BIMStone; BIMObjectName: 7432G(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 18/03/2022
Type - Green Building Properties - EAN Number: 6414150100109; EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822) Oras lab.; RSK Number: 8283208; Sales Package dimensions (LxWxH): 745 x 241 x 82; Sales Package gross weight: 3.635 kg; Sales Package package weight: 0.47088 kg; UNSPSC Class Number: 30181503 Showers; URL Declaration of Conformity: http://static.oras.com/DoC/7432G; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7432G; Catalog Drawing URL: http://static.oras.com/catdrw/7432G; Dimension Drawing URL: http://static.oras.com/dimdrw/7432G; FDV Document URL: http://www.oras.com/datasheet/7432G/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7432G; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7432G; Interactive AR View URL: https://static.oras.com/AR/7432G; Item Type: Sales item; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7432G; Model: 7432G Shower faucet with shower set, 40cc; Name_en: 7432G Shower faucet with shower set, 40cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7432G; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7432G; Product URL: http://static.oras.com/7432G; Technical DataSheet URL: http://www.oras.com/datasheet/7432G/en; Type Name: 7432G Shower faucet with shower set, 40cc; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Fine Textured - Black
Type - Mechanical - Backflow Prevention EN1717: EB; Eco Flow At 300kPa: 0.00353147 m3/s; Flow Rate At 300kPa: 0.000706293 m3/s; Hand Shower Size: Ø 70 mm; Installation Type: Wall mounted; Installation Width: cc40 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1500 mm);Eco flow control; Shower Spray: EcoSpray; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7443-33(2022); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7432G; Name: 7432G Shower faucet with shower set, 40cc; ReplacementCost: n/a; Shape: Sculptured; Size: 290x160x70 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7432G; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7432G Shower faucet with shower set, 40cc
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0820696 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 160 mm; OutletAngle: 0 deg; Volume: 0.00334995 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7443-33(2022): 7432G Shower faucet with shower set, 40cc; Family and Type: 7443-33(2022): 7432G Shower faucet with shower set, 40cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7443-33(2022): 7432G Shower faucet with shower set, 40cc; Type Id: 7443-33(2022): 7432G Shower faucet with shower set, 40cc; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
